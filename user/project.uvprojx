# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32F103xE, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: ..\rtthread\components\libc\compilers\common\extension;board\CubeMX_Config\Inc;..\rtthread\components\drivers\include;..\rtthread\components\drivers\include;..\rtthread\components\drivers\include;..\libraries\HAL_Drivers\CMSIS\Include;..\rtthread\components\libc\compilers\common\include;..\libraries\HAL_Drivers;..\rtthread\include;..\rtthread\libcpu\arm\cortex-m3;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\rtthread\libcpu\arm\common;..\rtthread\components\libc\posix\io\epoll;..\rtthread\components\libc\posix\io\eventfd;..\rtthread\components\libc\compilers\common\extension\fcntl\octal;..\rtthread\components\finsh;applications;..\rtthread\components\libc\posix\io\poll;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\rtthread\components\dfs\dfs_v1\include;..\libraries\HAL_Drivers\config;..\rtthread\components\libc\posix\ipc;..\rtthread\components\drivers\include;.;board\ports;board
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../rtthread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../rtthread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    ../rtthread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../rtthread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../rtthread/components/drivers/core/: device.c
    ../rtthread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../rtthread/components/drivers/misc/: pin.c
    ../rtthread/components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
  group Filesystem
    ../rtthread/components/dfs/dfs_v1/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    ../rtthread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../rtthread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
